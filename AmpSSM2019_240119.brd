# Repository hkr352/MicAmp_SSM2019

## EAGLE design AmpSSM2019_240119.brd

Parts:
C1, C2, C3, C6, C8, C10: 47u; CE-025X065
C4: 200p; C1206
C5, C7, C9: 1u; C1206
C11: 10u; CE-025X065
C12, C13: 0.01u; C0603
C14: 1000p; C1206
C15: 1u; C050-065X075
C16: 1u; C050-045X075
CN1, CN2, CN3: XH; B2B-XH-A
CN4: VH; VH5
D1, D2, D3, D4: ZD323; SOD-323
IC1: SSM2019BRNZRLDIP; DIL08
J1: MPJ-8004-3P
L1, L2, L3: 1mH/SRC1013; L13X15
LED1: LED3MM
PJ2: PJ3.5-2
R1, R2, R7: 10k; R0603
R3, R4: 6.8k; R0603
R5: 100; R0603
R6: 3R; R0603
R10: 2.7k; R0603
SW1: SW-1MS1-T1-B1-M1-Q-N; 1MS1-T1-B1-M1-Q-N
TP1, TP2: TPPAD1-13; P1-13
U1: OBS48SA-U
U2: UNIVERSAL10X10
U3, U4: OAS6R0-4815
U5: OAD3R0-4815
VR1: PCB-VR-2

Connections:
48V: C6.+, L1.2, SW1.P$2
+15V: C8.+, C13.2, IC1.7 (V+), L2.2
+IN: C1.+, J1.2, R3.2
+IN15V: C7.2, CN1.2, L2.1, U3.V_OUT (15V), U5.V+_OUT (+15V)
-15V: C10.-, C12.2, IC1.4 (V-), L3.2
-IN: C2.+, J1.3, R4.1
FG: CN4.1, U1.5 (FG)
GND: C7.1, C8.-, C9.1, C10.+, C12.1, C13.1, C14.1, CN1.1, CN3.2, D2.K (C), D3.K (C), IC1.5 (REFERENCE), PJ2.1 (S), R1.1, R2.2, R7.1, U3.G_OUT (GND), U4.V_OUT (15V), U5.G_OUT (GND)
GND_48: C3.-, C5.1, C6.-, C14.2, CN2.1, J1.1, J1.G, LED1.K (C), TP2.TP, U1.2 (GND), U3.G_IN (GND), U4.G_IN (GND), U5.G_IN (GND)
IN48V: C5.2, CN2.2, L1.1, TP1.TP, U1.1 (48V), U3.VIN (IN48V), U4.VIN (IN48V), U5.VIN (IN48V)
IN-15V: C9.2, CN3.1, L3.1, U4.G_OUT (GND), U5.V-_OUT (-15V)
L: CN4.5, U1.3 (L)
N: CN4.3, U1.4 (N)
unnamed: IC1.8 (RG2), R6.1
unnamed: IC1.1 (RG1), VR1.3 (1)
unnamed: R6.2, VR1.1 (3), VR1.2
unnamed: C1.-, C4.2, D1.K (C), IC1.3 (+IN), R1.2
unnamed: C11.+, IC1.6 (OUT)
unnamed: C2.-, C4.1, D4.K (C), IC1.2 (-IN), R2.1
unnamed: D1.A, D2.A
unnamed: C11.-, PJ2.3 (TIP), R7.2
unnamed: C3.+, R3.1, R4.2, R5.1
unnamed: D3.A, D4.A
unnamed: LED1.A, R10.1
P48V: R5.2, R10.2, SW1.P$3 (S)

Notes on the sheet:
電源 ローパスフィルタ
48V -> +15V
XLRコネクタ
3.5mm
100AV -> 48V
48V -> -15V
48V -> ±15V
SSM2019: MAX ±18V
セラコンは極力減らしてフィルムチップにする？
48V~63V
12V, 1/2W
220pF 500V C0G GRM31A5C2H221JW01D
C0G 0603~0805位が種類多い

Board: 2 copper layers, 80.0 x 100.0 mm, 48 parts (19 on the bottom side), 25 nets.

## Commit log

2024-02-22 first
